# Keil uVision project Moving Car V2.0.uvprojx, settings and files
target TM4C123GH6PM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Moving Car V2.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/gpio/: gpio.h gpio.c
    ./MCAL/gpt/: gpt.h gpt.c
  group HAL
    ./HAL/led/: led.h led.c
    ./HAL/button/: button.h button.c
    ./HAL/pwm/: pwm.h pwm.c
    ./HAL/dcm/: dcm.h dcm.c
    ./HAL/delay/: delay.h delay.c
    ./HAL/exti/: exti.h exti.c
  group APP
    ./APP/: app_interface.h app_config.h app_program.c
  group LIB
    ./LIB/: std_types.h common_macros.h registers.h
  group Main
    ./: main.h main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
