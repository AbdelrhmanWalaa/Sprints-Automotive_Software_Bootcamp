# Keil uVision project RGB LED Blinking.uvprojx, settings and files
target TM4C123GH6PM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RGB LED Blinking
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./: gpio_interface.h gpio_linkConfig.h gpio_private.h gpio_linkConfig.c gpio_program.c gptm_interface.h gptm_linkConfig.h gptm_private.h gptm_linkConfig.c gptm_program.c
  group HAL
    ./: led_interface.h led_program.c btn_interface.h btn_program.c pwm_interface.h pwm_config.h pwm_program.c
  group APP
    ./: app_interface.h app_program.c
  group LIB
    ./: std_types.h bit_math.h mcu_config.h Memory Map.txt
  group Main
    ./: main.h main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
